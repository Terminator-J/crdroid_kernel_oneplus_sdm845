## drivers/nfc/oplus_nfc/Kconfig
```kconfig
config OPLUS_NFC
  bool "config oplus nfc chipset"
  default n
  help
	define this config to get chipset version from dts.
```
